

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO et4351 
  PIN clk 
    ANTENNAPARTIALMETALAREA 2.8036 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.645 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 33.6091 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 153.778 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.613105 LAYER Via3 ;
  END clk
  PIN resetn 
    ANTENNAPARTIALMETALAREA 3.5884 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1478 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.023175 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 158.844 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 718.99 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.01079 LAYER Via3 ;
  END resetn
  PIN ser_tx 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.7996 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.627 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 20.458 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 113.997 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.27134 LAYER Via3 ;
  END ser_tx
  PIN ser_rx 
    ANTENNAPARTIALMETALAREA 1.3812 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2154 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 22.3319 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 102.178 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.403704 LAYER Via3 ;
  END ser_rx
  PIN flash_csb 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.7556 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4002 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 19.148 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 107.991 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.25869 LAYER Via3 ;
  END flash_csb
  PIN flash_clk 
    ANTENNADIFFAREA 3.839 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.74 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.33 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.1109 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 68.8441 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.40966 LAYER Via3 ;
  END flash_clk
  PIN flash_io0 
    ANTENNAPARTIALMETALAREA 0.0532 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2394 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNADIFFAREA 2.92225 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.796 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6396 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.266175 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 103.047 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 473.019 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 11.3875 LAYER Via4 ;
  END flash_io0
  PIN flash_io1 
    ANTENNADIFFAREA 2.92225 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.2212 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4954 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.266175 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 26.8099 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 154.2 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 11.3768 LAYER Via3 ;
  END flash_io1
  PIN flash_io2 
    ANTENNADIFFAREA 2.92225 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.3712 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.1992 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.266175 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 42.6407 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 198.806 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 11.378 LAYER Via3 ;
  END flash_io2
  PIN flash_io3 
    ANTENNAPARTIALMETALAREA 2.7092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1914 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.284 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3068 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 2.92225 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 2.3784 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7316 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.266175 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 28.3789 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 161.616 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 11.4298 LAYER Via5 ;
  END flash_io3
END et4351

END LIBRARY
